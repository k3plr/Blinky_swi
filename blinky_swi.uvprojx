# Keil uVision project blinky_swi.uvprojx, settings and files
target dbg (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky_swi
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c TM4C123GH6PM_Q.h
  group User Library
    ./: bsp.h bsp.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
